# IAR project Tbox.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKS22FN256xxx12 NXP MKS22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MKS22FN256VLL12; FSL_RTOS_FREE_RTOS; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../rtos/Source/portable/IAR/ARM_CM4F; ../rtos/Source/include; ../CMSIS/Include; ../devices/MKS22F12/drivers; ../devices/MKS22F12/utilities; ../rtos/Source; ../devices/MKS22F12; ..\source\board; ..\source\common; ..\source\SysMan; ..\source\Power; ..\source\GPS; ..\source\GPRS; ..\source\Diag_Factory; ..\source\user; ..\source\Can\sysdepend\KS22; ..\source\mbed_tls; ..\middleware\dma_manager_2.0.0; ..\source\uds-c\src; ..\source\uds-c\src\uds; ..\source\uds-c\deps\bitfield-c\src\; ..\source\uds-c\deps\isotp-c\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..\source\common; ..\source\board
  OBJCOPY.OOCOutputFile: Tbox.srec
  ILINK.IlinkOutputFile: Tbox.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MKS22xN256xxx12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../rtos/Source/portable/IAR/ARM_CM4F; ../rtos/Source/include; ../CMSIS/Include; ../devices/MKS22F12/drivers; ../devices/MKS22F12/utilities; ../rtos/Source; ../devices/MKS22F12; ..\source\board; ..\source\common; ..\source\SysMan; ..\source\Power; ..\source\GPS; ..\source\GPRS; ..\source\Diag_Factory; ..\source\user; ..\source\Can\sysdepend\KS22; ..\source\mbed_tls; .\middleware\dma_manager_2.0.0
  group doc
    ../: readme.txt
  group drivers
    ../devices/MKS22F12/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_flexcan.c fsl_flexcan.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_gpio.c fsl_gpio.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_freertos.h fsl_wdog.c fsl_wdog.h
  group drivers/freertos
    ../devices/MKS22F12/drivers/: fsl_dspi_freertos.c fsl_lpi2c_freertos.c fsl_lpuart.c fsl_lpuart.h fsl_lpuart_freertos.c fsl_uart_freertos.c
  group freertos
    ../rtos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/MemMang
    ../source/common/: FreeRTOSConfig.h
    ../rtos/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../rtos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group middleware/dma_manager_2.0.0
    ../middleware/dma_manager_2.0.0/: fsl_dma_manager.c fsl_dma_manager.h
  group source/board
    ../source/board/: adc.c adc.h board.c clock_config.c ITHandler.c rtc.c rtc.h spi_flash_freertos.c spi_flash_freertos.h uart.c wdog.c
    ../source/Power/: clock_mcg.c power_mode_switch.h
    ../source/common/: delay.c delay.h
  group source/can/sysdepend
    ../source/Can/sysdepend/KS22/: Can_Hw.c Can_Hw.h
  group source/common
    ../source/common/: crc_ccitt.c crc_ccitt.h diag_task.c diag_task.h gensubs.c gensubs.h param.c periodic.c periodic.h record_task.c record_task.h ring_buf.c ring_buf.h rtos.c rtos.h str_lib.c str_lib.h timer.c timer.h
  group source/GPRS
    ../source/GPRS/: GPRS.c GPRS.h iotrecv.c iotrecv.h iotsend.c iotsend.h TelmProtocol.c telmprotocol.h
  group source/GPS
    ../source/GPS/: gps.c gps.h
  group source/mbed_tls
    ../source/mbed_tls/: aes.c aes.h aesni.c aesni.h mbed_config.h padlock.c padlock.h
  group source/power
    ../source/Power/: ACC_Detect.c ACC_Detect.h BMS_Detect.c BMS_Detect.h ExtBatt_Detect.c ExtBatt_Detect.h fsm.c fsm.h lowpower.c power_mode_switch.c powerfail.c powerfail.h Psync.c psync.h relays.c relays.h
  group source/system
    ../source/SysMan/: system.c system.h
  group source/user
    ../source/user/: main.c vehicle.c vehicle.h
  group startup
    ../devices/MKS22F12/utilities/: fsl_debug_console.c
    ../devices/MKS22F12/iar/: startup_MKS22F12.s
    ../devices/MKS22F12/: system_MKS22F12.c
  group test
    ../source/test/: ADC16_Test.c ANT_test.c AutosarCanTest.c can_test.c chargeTest.c gpioTestWithoutRTOS.c gprs_test.c ledtest.c PINwakeupTest.c RTC_test.c spi_flash_test.c uart_test.c ublox_test.c
