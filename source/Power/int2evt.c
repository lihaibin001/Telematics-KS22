/* $Header:   int2evt.c  $*/
/**********************************************************************
 *       Title:   int2evt.c
 *
 * Description:  This is the standard code file for msync.  This module
 *                determines active primary audio source.
 *
 *      Author:   
 *
 *********************************************************************/
/**********************************************************************
 * Installation Instructions (periodic tasks, etc.)
 *
 *********************************************************************/

/**********************************************************************
 * Include header files
 *********************************************************************/
/*********************************************************************/
#include "standard.h"

/*********************************************************************
 * File level pragmas
 *********************************************************************/

/**********************************************************************
 * Constant and Macro Definitions using #define
 *********************************************************************/

 
/**********************************************************************
 * Enumerations and Structures and Typedefs
 *********************************************************************/
/**********************************************************************
 * Global and Const Variable Defining Definitions / Initializations
 *********************************************************************/

/**********************************************************************
 *********************************************************************/


/**********************************************************************
 * Function Prototypes for Private Functions with File Level Scope
 *********************************************************************/

/*====================================================================
 * Standard Event handlers
 *==================================================================*/
/**********************************************************************
 * Static Variables and Const Variables With File Level Scope
 *********************************************************************/

/**********************************************************************
 * ROM Const Variables With File Level Scope
 *********************************************************************/

/**********************************************************************
 * Add User defined functions
 *********************************************************************/

/**********************************************************************
 * Function Definitions
 *********************************************************************/

/**********************************************************************
 * Description: returns current main source
 *  Parameters: None
 *     Returns: current source
 *********************************************************************/
/*********************************************************************
 * Description: Converts a "message" based on state, mode, and state table
 *              to an 16 bit event code
 *  Parameters:
 *     Returns:  event code (from inp2evt tables)
 *********************************************************************/
int16_t Input_To_Event(Input_States_T *index, Message_Type msg, uint16_t mode, const INP2EVT_TABLE *inp2evt_table)
{
   int   i;
   int16_t       event;                           // return value

   event = EVT_NOP;                                // default event to do nothing

   if (0 != msg)
   {
         for   (i = 0; i < inp2evt_table->input_size; i++)
         {
            if (msg == inp2evt_table->input_table[i].msg)
            {
               if (0 != (mode & inp2evt_table->input_table[i].mode))
               {
                  break;
               }
            }
         }

         if (inp2evt_table->input_size == i)
         {
            return(EVT_NOT_FOUND);                 // return msg but no match
         }

         event = inp2evt_table->input_table[i].code;
         if (0 <= event)
         {
            return(event);
         }
  }
   
   return(event);
}

/**********************************************************************
 *
 * REVISION RECORDS
 *
 *********************************************************************/
/**********************************************************************
 *
 *********************************************************************/


